## config/boards/shields/niche104/KConfig.shield
```kconfig
# Copyright (c) 2021 Tyler Roy
# SPDX-License-Identifier: MIT

config SHIELD_NICHE104
	def_bool $(shields_list_contains,niche104)
```
